File: Hardware/IRsens/IRsens.brd (EAGLE design)
At the start: 15 x 15 mm, 10 parts

Commit message: hardware updates
Routing:
- net GND: track 34.2 -> 37.2 mm
